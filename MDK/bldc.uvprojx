# Keil uVision project bldc.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bldc
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\App;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Driver;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\software;..\Common;..\Device
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group STLib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c misc.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dma.c
  group Main
    ../: main.c stm32f10x_it.c
  group Driver
    ../Driver/: SysTick.c rcc.c key.c gpio.c led.c simSPI.c Driver.c ADC.c
  group Common
    ../Common/: FIFO.c
  group Device
    ../Device/: Nokia5110.c font.c
